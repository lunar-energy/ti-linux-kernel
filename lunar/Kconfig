## lunar/Kconfig
```kconfig
choice
	prompt "Lunar Hardware"
	default LUNAR_HC

config LUNAR_HC
	bool "HC"

endchoice
```
